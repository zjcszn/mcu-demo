# Keil uVision project Project.uvprojx, settings and files
target v2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: DJJ_V2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Version=2 NRF52832,NRF52,__FPU_PRESENT=1,__TARGET_FPU_VFP,CONFIG_NFCT_PINS_AS_GPIOSENABLE_SWO,ARM_MATH_CM4,HAVE_CONFIG_H
  c include: ..\HardWare;..\Libraries\drivers_nrf\adc;..\Libraries\drivers_nrf\ble_flash;..\Libraries\drivers_nrf\hal;..\Libraries\drivers_nrf\power;..\Libraries\drivers_nrf\radio_config;..\Libraries\drivers_nrf\spi_master;..\Libraries\drivers_nrf\systick;..\Libraries\drivers_nrf\timer;..\Libraries\drivers_nrf\uart;..\Libraries\drivers_nrf\wdt;..\Libraries\util;..\Libraries\device;..\Libraries\log;..\Libraries\proprietary_rf\esb;..\Libraries\drivers_nrf\delay;..\Libraries\drivers_nrf\nrf_soc_nosd;..\User;..\Libraries\drivers_nrf\common;..\Libraries\log\src;..\peripherals;..\Libraries\drivers_nrf\gpiote;..\Libraries\proprietary_rf\esb;..\APP;..\BaseStation\tcpip;..\Location;..\BaseStation;..\freertos\config;..\freertos\portable\ARM\nrf52;..\freertos\portable\CMSIS\nrf52;..\freertos\source\include;..\freertos\source\portable\Common;..\freertos\source\portable\MemMang;..\Libraries\drivers_nrf\clock;..\IAP;..\ThirdPath\freertos\config;..\ThirdPath\freertos\portable\ARM\nrf52;..\ThirdPath\freertos\portable\CMSIS\nrf52;..\ThirdPath\freertos\source\include;..\ThirdPath\freertos\source\portable\MemMang;..\Test;..\Application;..\Libraries\drivers_nrf\twi_master;..\Debug;..\Libraries\drivers_nrf\clock;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\CMSIS;..\Task;..\DSP\Include;..\Speex;..\Speex\Speex;..\Speex\Speex\include;..\Speex\Speex\include\speex;..\Speex\Speex\libspeex;..\Speex\SpeexDsp;..\Speex\SpeexDsp\include;..\Speex\SpeexDsp\include\speex;..\Speex\SpeexDsp\libspeexdsp;..\Fuction;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group System/Core
    ../User/: core.c
  group System/HardWare
    ../HardWare/: esb.c bsp.c i2c.c i2s.c
  group System/Periperhal
    ../HardWare/: wm8978.c
  group Middlewares/FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c cmsis_os.c cpu_utils.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/CMSIS/: port_cmsis_systick.c port_cmsis.c
  group Application/Fuction
    ../Application/: consert.c audioFuction.c
  group Middlewares/ARM_MATH
    ../DSP/: arm_cortexM4lf_math.lib
    ../DSP/Include/: arm_math.h
  group Application/Task
    ../Task/: task_audio.c task_keyscan.c task_rfIT.c task_sync.c testwav.c
    ../Application/: main.c
  group Middlewares/Speex
    ../Speex/Speex/libspeex/: bits.c cb_search.c exc_5_64_table.c exc_5_256_table.c exc_8_128_table.c exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c filters.c gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c kiss_fft.c kiss_fftr.c lpc.c lsp.c lsp_tables_nb.c ltp.c modes.c modes_wb.c nb_celp.c quant_lsp.c sb_celp.c smallft.c speex.c speex_callbacks.c speex_header.c stereo.c vbr.c vorbis_psy.c vq.c window.c
  group Middlewares/SpeexDSP
    ../Speex/SpeexDsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c mdf.c preprocess.c resample.c scal.c
    ../Speex/: speexC.c
software components: CMSIS:CORE 5.2.0, Device:Startup 8.29.0
