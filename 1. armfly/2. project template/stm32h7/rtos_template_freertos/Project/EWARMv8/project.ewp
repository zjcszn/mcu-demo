# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Libraries\STM32H7xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\IAR\ARM_CM7\r0p1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\User
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_dwt.c bsp_fmc_io.c bsp_key.c bsp_led.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group User
    ../../User/: FreeRTOSConfig.h includes.h main.c SysInfoTest.c
