# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c includes.h SysInfoTest.c FreeRTOSConfig.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_dwt.c bsp_led.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group FreeRTOS/Source
    ../../FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c event_groups.c stream_buffer.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
